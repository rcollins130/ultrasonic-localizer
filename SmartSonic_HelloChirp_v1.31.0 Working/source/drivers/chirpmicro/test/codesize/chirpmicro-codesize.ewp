# IAR project chirpmicro-codesize.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: chirpmicro-codesize.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: chbsp_chirp_dummy.c main.c
  group inc
    ../../inc/: ch101.h ch101_floor.h ch101_gpr_open.h ch101_gpr_sr_open.h ch201.h ch201_gprstr.h ch201_gprmt.h ch201_presence.h ch_common.h ch_driver.h ch_math_utils.h chirp_bsp.h soniclib.h
  group src
    ../../src/: ch101_floor.c ch101_floor_fw.c ch101_gpr_open.c ch101_gpr_open_fw.c ch101_gpr_sr_open.c ch101_gpr_sr_open_fw.c ch201_gprstr.c ch201_gprstr_fw.c ch201_gprmt.c ch201_gprmt_fw.c ch201_presence.c ch201_presence_fw.c ch_api.c ch_common.c ch_driver.c ch_math_utils.c chbsp_dummy.c
